require arm-trusted-firmware.inc

LIC_FILES_CHKSUM = "file://docs/license.rst;md5=b2c740efedc159745b9b31f88ff03dde"

ATF_VERSION = "v2.7.0"
ATF_BRANCH = "socfpga_${ATF_VERSION}"

SRCREV = "9ef7477e709d493b56f269b2407a61afb3b28883"
