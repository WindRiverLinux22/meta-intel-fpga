require arm-trusted-firmware.inc

LIC_FILES_CHKSUM = "file://docs/license.rst;md5=b2c740efedc159745b9b31f88ff03dde"

ATF_VERSION = "v2.6.0"
ATF_BRANCH = "socfpga_${ATF_VERSION}"

SRCREV = "2c26c0efb117d8a5bb02379f7d439373cd703cfd"
